<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Concurrently_Multi_Channel_NFM_Receiver_MWK_13_VFOs</value></param>
<param><key>author</key><value>MWK</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>MWK Multi Channels Scanner 13 VFOs</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>MWK_Multi_Channels_NFM_Scanner_13_VFOs</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>422.9e6</value></param>
<param><key>label</key><value>Center Freq.</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq1</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>422.5375e6</value></param>
<param><key>grid_pos</key><value>2,16,1,4</value></param>
<param><key>label</key><value>VFO-8</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq2</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>422.9375e6</value></param>
<param><key>grid_pos</key><value>1,4,1,4</value></param>
<param><key>label</key><value>VFO-1</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq_10</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>423.3275e6</value></param>
<param><key>grid_pos</key><value>3,4,1,4</value></param>
<param><key>label</key><value>VFO-10</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq_11</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>425.175e6</value></param>
<param><key>grid_pos</key><value>3,8,1,4</value></param>
<param><key>label</key><value>VFO-11</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq_12</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>424.588e6</value></param>
<param><key>grid_pos</key><value>3,12,1,4</value></param>
<param><key>label</key><value>VFO-12</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq_13</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>424.786e6</value></param>
<param><key>grid_pos</key><value>3,16,1,4</value></param>
<param><key>label</key><value>VFO-13</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq_3</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>423.3375e6</value></param>
<param><key>grid_pos</key><value>1,8,1,4</value></param>
<param><key>label</key><value>VFO-2</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq_4</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>423.1375e6</value></param>
<param><key>grid_pos</key><value>2,4,1,4</value></param>
<param><key>label</key><value>VFO-5</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq_5</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>423.1625e6</value></param>
<param><key>grid_pos</key><value>2,8,1,4</value></param>
<param><key>label</key><value>VFO-6</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq_6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>423.4875e6</value></param>
<param><key>grid_pos</key><value>2,12,1,4</value></param>
<param><key>label</key><value>VFO-7</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq_7</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>422.300e6</value></param>
<param><key>grid_pos</key><value>2,0,1,4</value></param>
<param><key>label</key><value>VFO-4</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq_8</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>422.8875e6</value></param>
<param><key>grid_pos</key><value>1,12,1,4</value></param>
<param><key>label</key><value>VFO-3</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_freq_9</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>423.1275e6</value></param>
<param><key>grid_pos</key><value>3,0,1,4</value></param>
<param><key>label</key><value>VFO-9</value></param>
<param><key>max</key><value>470e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_width</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>down_rate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ppm_correction</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>PPM Corr.</value></param>
<param><key>max</key><value>60</value></param>
<param><key>min</key><value>-60</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>15</value></param>
<param><key>grid_pos</key><value>1,0,1,4</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>max</key><value>48</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>12</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>sql_lev</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>-50</value></param>
<param><key>grid_pos</key><value>1,16,1,4</value></param>
<param><key>label</key><value>SQL</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>volume</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>100</value></param>
<param><key>grid_pos</key><value>0,16,1,1</value></param>
<param><key>label</key><value>Vol.</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0_0_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0_0_1</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0_0_2</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0_0_2_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0_0_2_1</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0_0_2_1_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0_0_2_1_1</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0_0_2_1_2</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0_0_2_1_3</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0_0_2_1_4</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_1</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>15000</value></param>
<param><key>audio_stop</key><value>16000</value></param>
<param><key>chan_rate</key><value>down_rate</value></param>
<param><key>deviation</key><value>75000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>1</value></param>
<param><key>threshold</key><value>sql_lev</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq1</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq2</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq_3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq_4</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq_5</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_2</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq_6</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_2_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq_7</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_2_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq_8</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_2_1_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq_8</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_2_1_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq_8</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_2_1_2</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq_8</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_2_1_3</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq_8</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_2_1_4</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>center_freq - channel_freq_8</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0_0_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0_0_1</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0_0_2</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0_0_2_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_1</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_2</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_2_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_2_1</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_2_2</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_2_3</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_2_4</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>threshold</key><value>-50</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>24000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>13</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_0</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_1</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_2</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_2_0</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_2_1</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_2_1_0</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_2_1_1</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_2_1_2</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_2_1_3</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_2_1_4</value></param>
<param><key>const</key><value>volume/100</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1_2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1_2_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1_2_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1_2_1_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1_2_1_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1_2_1_2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1_2_1_3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1_2_1_4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_2_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_2_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_2_1_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_2_1_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_2_1_2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_2_1_3</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_2_1_4</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1_0</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1_1</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1_2</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1_2_0</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1_2_1</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1_2_1_0</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1_2_1_1</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1_2_1_2</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1_2_1_3</value></param>
<param><key>cutoff_freq</key><value>1e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1_2_1_4</value></param>
<param><key>cutoff_freq</key><value>0.5e3</value></param>
<param><key>decim</key><value>int(samp_rate/channel_width)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>12.5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>ppm_correction</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_0</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_1</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_2</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_2_0</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_2_1</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_2_1_0</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_2_1_1</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_2_1_2</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_2_1_3</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_2_1_4</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>MWK Concurrently Multi Channels NFM 13 VFOs Memory Scanner</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>analog_fm_demod_cf_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0_0_1</source_block_id><sink_block_id>rational_resampler_xxx_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0_0_2</source_block_id><sink_block_id>rational_resampler_xxx_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0_0_2_0</source_block_id><sink_block_id>rational_resampler_xxx_0_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0_0_2_1</source_block_id><sink_block_id>rational_resampler_xxx_0_1_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0_0_2_1_0</source_block_id><sink_block_id>rational_resampler_xxx_0_1_2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0_0_2_1_1</source_block_id><sink_block_id>rational_resampler_xxx_0_1_2_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0_0_2_1_2</source_block_id><sink_block_id>rational_resampler_xxx_0_1_2_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0_0_2_1_3</source_block_id><sink_block_id>rational_resampler_xxx_0_1_2_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0_0_2_1_4</source_block_id><sink_block_id>rational_resampler_xxx_0_1_2_1_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_1</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_1</source_block_id><sink_block_id>blocks_multiply_xx_0_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_2</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_2_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_2_1</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_2_1_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_2_1_1</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_2_1_2</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_1_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_2_1_3</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_1_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_2_1_4</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_1_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0_0_0</source_block_id><sink_block_id>blocks_throttle_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0_0_1</source_block_id><sink_block_id>blocks_throttle_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0_0_2</source_block_id><sink_block_id>blocks_throttle_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0_0_2_0</source_block_id><sink_block_id>blocks_throttle_0_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_1</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_2</source_block_id><sink_block_id>blocks_throttle_0_0_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_2_0</source_block_id><sink_block_id>blocks_throttle_0_0_2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_2_1</source_block_id><sink_block_id>blocks_throttle_0_0_2_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_2_2</source_block_id><sink_block_id>blocks_throttle_0_0_2_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_2_3</source_block_id><sink_block_id>blocks_throttle_0_0_2_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_2_4</source_block_id><sink_block_id>blocks_throttle_0_0_2_1_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_2_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_2_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_2_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_2_1_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_2_1_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_2_1_3</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_2_1_4</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1</source_block_id><sink_block_id>low_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1_0</source_block_id><sink_block_id>low_pass_filter_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1_1</source_block_id><sink_block_id>low_pass_filter_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1_2</source_block_id><sink_block_id>low_pass_filter_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1_2_0</source_block_id><sink_block_id>low_pass_filter_0_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1_2_1</source_block_id><sink_block_id>low_pass_filter_0_1_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1_2_1_0</source_block_id><sink_block_id>low_pass_filter_0_1_2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1_2_1_1</source_block_id><sink_block_id>low_pass_filter_0_1_2_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1_2_1_2</source_block_id><sink_block_id>low_pass_filter_0_1_2_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1_2_1_3</source_block_id><sink_block_id>low_pass_filter_0_1_2_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1_2_1_4</source_block_id><sink_block_id>low_pass_filter_0_1_2_1_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>analog_fm_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>analog_fm_demod_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0</source_block_id><sink_block_id>analog_fm_demod_cf_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_1</source_block_id><sink_block_id>analog_fm_demod_cf_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_2</source_block_id><sink_block_id>analog_fm_demod_cf_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_2_0</source_block_id><sink_block_id>analog_fm_demod_cf_0_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_2_1</source_block_id><sink_block_id>analog_fm_demod_cf_0_0_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_2_1_0</source_block_id><sink_block_id>analog_fm_demod_cf_0_0_2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_2_1_1</source_block_id><sink_block_id>analog_fm_demod_cf_0_0_2_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_2_1_2</source_block_id><sink_block_id>analog_fm_demod_cf_0_0_2_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_2_1_3</source_block_id><sink_block_id>analog_fm_demod_cf_0_0_2_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_2_1_4</source_block_id><sink_block_id>analog_fm_demod_cf_0_0_2_1_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>analog_fm_demod_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_simple_squelch_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>analog_simple_squelch_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1</source_block_id><sink_block_id>analog_simple_squelch_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_0</source_block_id><sink_block_id>analog_simple_squelch_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_1</source_block_id><sink_block_id>analog_simple_squelch_cc_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_2</source_block_id><sink_block_id>analog_simple_squelch_cc_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_2_0</source_block_id><sink_block_id>analog_simple_squelch_cc_0_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_2_1</source_block_id><sink_block_id>analog_simple_squelch_cc_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_2_1_0</source_block_id><sink_block_id>analog_simple_squelch_cc_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_2_1_1</source_block_id><sink_block_id>analog_simple_squelch_cc_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_2_1_2</source_block_id><sink_block_id>analog_simple_squelch_cc_2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_2_1_3</source_block_id><sink_block_id>analog_simple_squelch_cc_2_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_2_1_4</source_block_id><sink_block_id>analog_simple_squelch_cc_2_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1_2_1_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_2_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_2_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_2_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_2_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_2_1_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_2_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_2_1_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_2_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_2_1_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_2_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_2_1_4</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_2_1_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
